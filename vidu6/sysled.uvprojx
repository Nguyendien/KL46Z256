# Keil uVision project sysled.uvprojx, settings and files
target sysled (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.10.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: sysled
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: led.c main.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
